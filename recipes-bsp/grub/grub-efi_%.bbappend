FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-search-Support-searching-for-GPT-partition-label-wit.patch"

